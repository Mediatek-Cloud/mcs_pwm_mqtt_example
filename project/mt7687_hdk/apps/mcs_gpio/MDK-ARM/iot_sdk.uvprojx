# Keil uVision project iot_sdk.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.3.1.0
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iot_sdk +hex
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: PCFG_OS=2 _REENT_SMALL MTK_SYS_TRNG_ENABLE MTK_NVRAM_ENABLE MTK_WIFI_API_TEST_CLI_ENABLE MTK_MINISUPP_ENABLE MTK_MINICLI_ENABLE MTK_BSP_INBAND_NEW_ENABLE MTK_BSP_LOAD_WIFI_PROFILE_ENABLE MTK_BSPEXT_ENABLE  MTK_TFTP_ENABLE MTK_HAL_LOWPOWER_ENABLE MTK_LWIP_ENABLE MTK_IPERF_ENABLE PRODUCT_VERSION=7687 MTK_WIFI_TGN_VERIFY_ENABLE MTK_SMTCN_ENABLE MTK_WIFI_WPS_ENABLE MTK_CLI_TEST_MODE_ENABLE MTK_WIFI_REPEATER_ENABLE N9_DUAL_INF_READY CONFIG_DUAL_INTERFACE MTK_DEBUG_LEVEL_INFO MTK_DEBUG_LEVEL_WARNING MTK_DEBUG_LEVEL_ERROR
  c misc: --C99
  c include: ..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\kernel\rtos\FreeRTOS\inc;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\project\mt7687_hdk\test_cases\sys_init_test\inc;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\board\mt76x7_hdk\wifi\inc;..\..\..\..\..\middleware\third_party\dhcpd\inc;..\..\..\..\..\middleware\MTK\minicli\inc;..\..\..\..\..\middleware\MTK\minisupp\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\..\..\..\middleware\third_party\lwip\src\include;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\project\common\bsp_ex\inc;..\..\..\..\..\middleware\MTK\nvdm\inc;..\..\..\..\..\middleware\MTK\nvram\inc;..\..\..\..\..\middleware\MTK\nvdm\src\portable;..\..\..\..\..\middleware\third_party\ping\inc;..\..\..\..\..\middleware\MTK\smtcn\inc;..\..\..\..\..\middleware\MTK\iperf\inc;..\..\..\..\..\project\mt7687_hdk\apps\iot_sdk\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\board\mt76x7_hdk\init\inc;..\..\..\..\..\driver\board\mt76x7_hdk\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __Vectors
  group app
    ../src/: main.c cli_def.c io_def.c system_mt7687.c task_def.c net_init.c
  group cmsis
    ./: startup_mt7687.s
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/src/: os_cli.c
  group bsp
    ../../../../../driver/board/mt76x7_hdk/src/: get_profile_string.c misc.c network_init.c os_util.c os_utils.c wifi_inband_cli.c wifi_profile.c wifi_wps.c
  group smtcn_core
    ../../../../../middleware/MTK/smtcn/lib/: libsmtcn_core_CM4_Keil.lib
  group minisupp
    ../../../../../middleware/MTK/minisupp/lib/: libminisupp_wps_CM4_Keil.lib
  group hal
    ../../../../../driver/chip/mt7687/src/common/: cos_api.c dma.c flash_sfc.c gpt.c hal_gpc.c hal_gpio_7687.c hal_I2C.c hal_i2s_internal.c hal_irrx.c hal_lp.c hal_pcnt.c hal_pinmux.c hal_spim.c hal_sys.c hal_trng.c hal_uid.c i2c.c ir_tx.c low_hal_gpio.c low_hal_irrx.c low_hal_irtx.c low_hal_pwm.c low_hal_rtc.c low_hal_wdt.c nvic.c pinmux.c pwm.c sfc.c spi_flash.c spim.c timer.c top.c uart.c
    ../../../../../driver/chip/mt7687/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_des.c hal_eint.c hal_flash.c hal_gdma.c hal_gpio.c hal_gpt.c hal_i2c_master.c hal_i2s.c hal_irtx.c hal_log.c hal_md5.c hal_pwm.c hal_rtc.c hal_sha.c hal_spi_master.c hal_uart.c hal_wdt.c
    ../../../../../driver/chip/mt7687/src/sdio_gen3/: connsys_util.c connsys_bus.c connsys_driver.c
    ../../../../../driver/chip/mt7687/lib/: libcrypto_CM4_Keil.lib libhal_core_CM4_Keil.lib
  group nvram
    ../../../../../middleware/MTK/nvram/lib/: libnvram_CM4_Keil.lib
  group minicli
    ../../../../../middleware/MTK/minicli/lib/: libminicli_CM4_Keil.lib
  group LwIP
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c pbuf.c sys_arch.c tcp_out.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c pppapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../../../middleware/third_party/lwip/src/core/: def.c dhcp.c dns.c inet_chksum.c init.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c timers.c udp.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c sha1.c md5.c
    ../../../../../middleware/third_party/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c ppp.c pppcrypt.c pppoe.c pppos.c upap.c vj.c utils.c
    ../../../../../middleware/third_party/lwip/src/netif/: etharp.c slipif.c
  group dhcpd
    ../../../../../middleware/third_party/dhcpd/src/: dhcpd.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c wifi_ex_cli.c wifi_ex_config.c wifi_ex_connect.c wifi_ex_profile.c
  group bsp_sec
    ../../../../../driver/board/mt76x7_hdk/lib/: libbsp_sec_CM4_Keil.lib
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: elian.c smt_conn.c
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_task.c iperf_cli.c
  group kservice
    ../../../../../kernel/service/src/: memory_regions.c
    ../../../../../kernel/service/lib/: libkservice_CM4_MT7687_Keil.lib
